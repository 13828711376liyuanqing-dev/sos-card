# Keil uVision project YP001_GR5526.uvprojx, settings and files
target YP001_GR5526_AC6 (6140000::V6.14::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: YP001_GR5526 +hex
  AfterMake: fromelf.exe --text -c --output Listings\@L.s   Objects\@L.axf
  AfterMake: fromelf.exe --bin --output Listings\@L.bin Objects\@L.axf
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: ENV_USE_FREERTOS,TK_Board_UART_DBG=1,YP001_BOARD,LV_LVGL_H_INCLUDE_SIMPLE,__MODULE__=__FILE__,YP001_OTA_USB_BENCH_TEST=1,EPAPER_UI_FACTORY_TEST=1
  c misc: -std=c99 -Wall
  c include: ..\..\SDK\components\libraries\app_bootloader\sign_verify\inc;..\Src\user\gui\guider;..\Src\user\gui\guider\custom;..\Src\config;..\Src\platform;..\Src\user;..\Src\external\qpc_7.3.4\qpc\include;..\Src\external\cJSON-1.7.19;..\Src\external\slre-1.3;..\Src\external\lvgl_8.3.1;..\..\SDK\components\drivers_ext\gr55xx;..\..\SDK\components\libraries\app_alarm;..\..\SDK\components\libraries\app_assert;..\..\SDK\components\libraries\app_error;..\..\SDK\components\libraries\app_key;..\..\SDK\components\libraries\app_log;..\..\SDK\components\libraries\app_queue;..\..\SDK\components\libraries\app_timer;..\..\SDK\components\libraries\at_cmd;..\..\SDK\components\libraries\ble\ble_time;..\..\SDK\components\libraries\dfu_master;..\..\SDK\components\libraries\dfu_port;..\..\SDK\components\libraries\hal_flash;..\..\SDK\components\libraries\hci_uart;..\..\SDK\components\libraries\pmu_calibration;..\..\SDK\components\libraries\ring_buffer;..\..\SDK\components\libraries\sensorsim;..\..\SDK\components\libraries\utility;..\..\SDK\components\libraries\ble\ble_scanner;..\..\SDK\components\profiles\ams_c;..\..\SDK\components\profiles\ancs_c;..\..\SDK\components\profiles\ans;..\..\SDK\components\profiles\ans_c;..\..\SDK\components\profiles\bas;..\..\SDK\components\profiles\bas_c;..\..\SDK\components\profiles\bps;..\..\SDK\components\profiles\common;..\..\SDK\components\profiles\cscs;..\..\SDK\components\profiles\cts;..\..\SDK\components\profiles\cts_c;..\..\SDK\components\profiles\dis;..\..\SDK\components\profiles\dis_c;..\..\SDK\components\profiles\gus;..\..\SDK\components\profiles\gus_c;..\..\SDK\components\profiles\hids;..\..\SDK\components\profiles\hrrcps;..\..\SDK\components\profiles\hrs;..\..\SDK\components\profiles\hrs_c;..\..\SDK\components\profiles\hts;..\..\SDK\components\profiles\ias;..\..\SDK\components\profiles\lls;..\..\SDK\components\profiles\ndcs;..\..\SDK\components\profiles\otas;..\..\SDK\components\profiles\otas_c;..\..\SDK\components\profiles\pass;..\..\SDK\components\profiles\pass_c;..\..\SDK\components\profiles\pcs;..\..\SDK\components\profiles\rscs;..\..\SDK\components\profiles\rscs_c;..\..\SDK\components\profiles\rtus;..\..\SDK\components\profiles\sample;..\..\SDK\components\profiles\ths;..\..\SDK\components\profiles\ths_c;..\..\SDK\components\profiles\tps;..\..\SDK\components\sdk\;..\..\SDK\drivers\inc;..\..\SDK\drivers\inc\hal;..\..\SDK\external\freertos\include;..\..\SDK\external\segger_rtt;..\..\SDK\platform\arch\arm\cortex-m\cmsis\core\include;..\..\SDK\platform\boards;..\..\SDK\platform\include;..\..\SDK\platform\soc\include;..\..\SDK\platform\soc\linker\keil;..\Src\external\qpc_7.3.4\qpc\ports\arm-cm\qv\armclang;..\Src\external\qpc_7.3.4\qpc\ports\arm-cm\qv\config;..\..\SDK\components\profiles\lms;..\..\SDK\components\libraries\app_graphics_mem
  asm include: ..\..\SDK\platform\arch\arm\cortex-m\cmsis\core\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: YP001_GR5526.sct
  link misc: ..\..\SDK\platform\soc\linker\keil\rom_symbol.txt
  group gr_startup
    ../../SDK/platform/arch/arm/cortex-m/keil/: Startup.S
  group gr_stack_lib
    ../../SDK/platform/soc/linker/keil/: ble_sdk.lib graphics_sdk.lib
  group gr_sdk_sources
    ../../SDK/platform/soc/common/: gr_system.c gr_interrupt.c gr_platform.c
    ../../SDK/platform/soc/src/: gr_soc.c
    ../../SDK/platform/boards/: board_SK.c
    ../../SDK/drivers/src/: app_dma.c app_gpiote.c app_io.c app_pwr_mgmt.c app_uart.c app_uart_dma.c app_i2c.c app_i2c_dma.c app_adc.c app_adc_dma.c app_rtc.c app_aon_wdt.c app_graphics_ospi.c
    ../../SDK/components/libraries/ble/ble_scanner/: ble_scanner.c
    ../../SDK/components/libraries/app_key/: app_key.c app_key_core.c
    ../../SDK/components/libraries/ring_buffer/: ring_buffer.c
    ../../SDK/components/libraries/utility/: utility.c
    ../../SDK/components/libraries/sensorsim/: sensorsim.c
    ../../SDK/components/libraries/pmu_calibration/: pmu_calibration.c
    ../../SDK/components/libraries/app_timer/: app_timer.c
    ../../SDK/components/libraries/app_assert/: app_assert.c
    ../../SDK/components/libraries/app_error/: app_error.c
    ../../SDK/components/libraries/app_log/: app_log.c app_log_dump_port.c app_log_store.c
    ../../SDK/components/libraries/ble/ble_time/: ble_time.c
    ../../SDK/components/sdk/: ble.c
    ../../SDK/components/profiles/common/: ble_prf_utils.c
    ../../SDK/components/profiles/gus/: gus.c
    ../../SDK/components/profiles/gus_c/: gus_c.c
    ../../SDK/external/segger_rtt/: SEGGER_RTT.c
    ../../SDK/components/profiles/lms/: lms.c
    ../../SDK/components/libraries/app_graphics_mem/: app_graphics_mem.c
  group gr_application
    ../Src/user/: app.c at_cmds.c blinky.c cat1svr.c cli.c da221.c da221_config.c epaper_depg0150.c epaper_depg0150_logo_yp01.c gpio_test.c gsensor_probe.c location_servise.c log_cmd.c main.c sensor.c transport_scheduler.c user_app.c yp001_battery.c yp001_psram_mem.c yp001_scan_sched.c
    ../Src/platform/: bsp.c user_periph_setup.c
    ../Src/external/cJSON-1.7.19/: cJSON.c
    ../Src/user/gui/: epaper_home.c epaper_lvgl.c
    ../Src/external/qpc_7.3.4/qpc/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../Src/external/qpc_7.3.4/qpc/src/qv/: qv.c
    ../Src/external/slre-1.3/: slre.c
    ../Src/user/business/: yp001_business.c yp_name_glyphs.c
    ../Src/user/charger/: yp001_charger.c yp001_charger_cli.c
    ../Src/user/factory/: yp001_factory_ble.c
    ../Src/user/ota/: yp001_ota.c yp001_ota_boot.c yp001_ota_wire.c yp001_ota_receive.c yp001_ota_app_crypto.c yp001_ota_project_verify.c yp001_ota_port.c
    ../../SDK/components/libraries/app_bootloader/sign_verify/src/: rsa.c pkc.c
  group lvgl_8_3_1
    ../Src/external/lvgl_8.3.1/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Src/external/lvgl_8.3.1/src/draw/arm2d/: lv_gpu_arm2d.c
    ../Src/external/lvgl_8.3.1/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Src/external/lvgl_8.3.1/src/draw/nxp/: lv_gpu_nxp.c
    ../Src/external/lvgl_8.3.1/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../Src/external/lvgl_8.3.1/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_rect.c lv_gpu_nxp_vglite.c
    ../Src/external/lvgl_8.3.1/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Src/external/lvgl_8.3.1/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Src/external/lvgl_8.3.1/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Src/external/lvgl_8.3.1/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../Src/external/lvgl_8.3.1/src/extra/layouts/flex/: lv_flex.c
    ../Src/external/lvgl_8.3.1/src/extra/layouts/grid/: lv_grid.c
    ../Src/external/lvgl_8.3.1/src/extra/libs/bmp/: lv_bmp.c
    ../Src/external/lvgl_8.3.1/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Src/external/lvgl_8.3.1/src/extra/libs/freetype/: lv_freetype.c
    ../Src/external/lvgl_8.3.1/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Src/external/lvgl_8.3.1/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Src/external/lvgl_8.3.1/src/extra/libs/png/: lodepng.c lv_png.c
    ../Src/external/lvgl_8.3.1/src/extra/libs/qrcode/: qrcodegen.c lv_qrcode.c
    ../Src/external/lvgl_8.3.1/src/extra/libs/rlottie/: lv_rlottie.c
    ../Src/external/lvgl_8.3.1/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Src/external/lvgl_8.3.1/src/extra/: lv_extra.c
    ../Src/external/lvgl_8.3.1/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Src/external/lvgl_8.3.1/src/extra/others/gridnav/: lv_gridnav.c
    ../Src/external/lvgl_8.3.1/src/extra/others/ime/: lv_ime_pinyin.c
    ../Src/external/lvgl_8.3.1/src/extra/others/imgfont/: lv_imgfont.c
    ../Src/external/lvgl_8.3.1/src/extra/others/monkey/: lv_monkey.c
    ../Src/external/lvgl_8.3.1/src/extra/others/msg/: lv_msg.c
    ../Src/external/lvgl_8.3.1/src/extra/others/snapshot/: lv_snapshot.c
    ../Src/external/lvgl_8.3.1/src/extra/themes/basic/: lv_theme_basic.c
    ../Src/external/lvgl_8.3.1/src/extra/themes/default/: lv_theme_default.c
    ../Src/external/lvgl_8.3.1/src/extra/themes/mono/: lv_theme_mono.c
    ../Src/external/lvgl_8.3.1/src/extra/themes/simplify/: lv_theme_simplify.c
    ../Src/external/lvgl_8.3.1/src/extra/widgets/animimg/: lv_animimg.c
    ../Src/external/lvgl_8.3.1/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Src/external/lvgl_8.3.1/src/extra/widgets/chart/: lv_chart.c
    ../Src/external/lvgl_8.3.1/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Src/external/lvgl_8.3.1/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Src/external/lvgl_8.3.1/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Src/external/lvgl_8.3.1/src/extra/widgets/led/: lv_led.c
    ../Src/external/lvgl_8.3.1/src/extra/widgets/list/: lv_list.c
    ../Src/external/lvgl_8.3.1/src/extra/widgets/menu/: lv_menu.c
    ../Src/external/lvgl_8.3.1/src/extra/widgets/meter/: lv_meter.c
    ../Src/external/lvgl_8.3.1/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Src/external/lvgl_8.3.1/src/extra/widgets/span/: lv_span.c
    ../Src/external/lvgl_8.3.1/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Src/external/lvgl_8.3.1/src/extra/widgets/spinner/: lv_spinner.c
    ../Src/external/lvgl_8.3.1/src/extra/widgets/tabview/: lv_tabview.c
    ../Src/external/lvgl_8.3.1/src/extra/widgets/tileview/: lv_fast_tileview.c lv_tileview.c
    ../Src/external/lvgl_8.3.1/src/extra/widgets/win/: lv_win.c
    ../Src/external/lvgl_8.3.1/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../Src/external/lvgl_8.3.1/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Src/external/lvgl_8.3.1/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Src/external/lvgl_8.3.1/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group gr_qpc_armclang
    ../Src/external/qpc_7.3.4/qpc/ports/arm-cm/qv/armclang/: qv_port.c
  group GUI Guider
    ../Src/user/gui/: epaper_ui.c epaper_ftest.c
    ../Src/user/gui/guider/: events_init.c gui_guider.c setup_scr_screen.c setup_scr_screen_callend.c setup_scr_screen_calling.c setup_scr_screen_lowbat.c setup_scr_screen_main.c setup_scr_screen_time.c widgets_init.c
    ../Src/user/gui/guider/custom/: custom.c
    ../Src/user/gui/guider/guider_fonts/: font_cn_16.c font_cn_24.c font_cn_28.c font_cn_32.c font_cn_40.c
    ../Src/user/gui/guider/images/: _battery_1_alpha_20x10.c _battery_4_alpha_20x10.c _icon_call_connected_alpha_200x200.c _icon_call_end_alpha_200x200.c _icon_sos_alpha_200x200.c _qr_imei_alpha_116x116.c
