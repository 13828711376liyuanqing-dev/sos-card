# Keil uVision project YP001_OTA_BOOT.uvprojx, settings and files
target YP001_OTA_BOOT_CANDIDATE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: YP001_OTA_BOOT_CANDIDATE
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOOTLOADER_ENABLE,WDT_RUN_ENABLE=1,BOOT_LONG_TIME=0
  c include: D:\CODEX\sos-card\tools\ota\gr_boot\Src\config;D:\CODEX\sos-card\tools\ota\gr_boot\Src\platform;D:\CODEX\sos-card\tools\ota\gr_boot\Src\user;D:\CODEX\sos-card\tools\ota\gr_boot\Src\config;D:\CODEX\sos-card\SDK\components\drivers_ext\gr55xx;D:\CODEX\sos-card\SDK\components\libraries\app_alarm;D:\CODEX\sos-card\SDK\components\libraries\app_assert;D:\CODEX\sos-card\SDK\components\libraries\app_error;D:\CODEX\sos-card\SDK\components\libraries\app_key;D:\CODEX\sos-card\SDK\components\libraries\app_log;D:\CODEX\sos-card\SDK\components\libraries\app_queue;D:\CODEX\sos-card\SDK\components\libraries\app_timer;D:\CODEX\sos-card\SDK\components\libraries\at_cmd;D:\CODEX\sos-card\SDK\components\libraries\dfu_master;D:\CODEX\sos-card\SDK\components\libraries\hal_flash;D:\CODEX\sos-card\SDK\components\libraries\hci_uart;D:\CODEX\sos-card\SDK\components\libraries\pmu_calibration;D:\CODEX\sos-card\SDK\components\libraries\ring_buffer;D:\CODEX\sos-card\SDK\components\libraries\sensorsim;D:\CODEX\sos-card\SDK\components\libraries\utility;D:\CODEX\sos-card\SDK\components\libraries\dfu_port;D:\CODEX\sos-card\SDK\components\profiles\ams_c;D:\CODEX\sos-card\SDK\components\profiles\ancs_c;D:\CODEX\sos-card\SDK\components\profiles\ans;D:\CODEX\sos-card\SDK\components\profiles\ans_c;D:\CODEX\sos-card\SDK\components\profiles\bas;D:\CODEX\sos-card\SDK\components\profiles\bas_c;D:\CODEX\sos-card\SDK\components\profiles\bps;D:\CODEX\sos-card\SDK\components\profiles\common;D:\CODEX\sos-card\SDK\components\profiles\cscs;D:\CODEX\sos-card\SDK\components\profiles\cts;D:\CODEX\sos-card\SDK\components\profiles\cts_c;D:\CODEX\sos-card\SDK\components\profiles\dis;D:\CODEX\sos-card\SDK\components\profiles\dis_c;D:\CODEX\sos-card\SDK\components\profiles\gus;D:\CODEX\sos-card\SDK\components\profiles\gus_c;D:\CODEX\sos-card\SDK\components\profiles\hids;D:\CODEX\sos-card\SDK\components\profiles\hrrcps;D:\CODEX\sos-card\SDK\components\profiles\hrs;D:\CODEX\sos-card\SDK\components\profiles\hrs_c;D:\CODEX\sos-card\SDK\components\profiles\hts;D:\CODEX\sos-card\SDK\components\profiles\ias;D:\CODEX\sos-card\SDK\components\profiles\lls;D:\CODEX\sos-card\SDK\components\profiles\ndcs;D:\CODEX\sos-card\SDK\components\profiles\otas_c;D:\CODEX\sos-card\SDK\components\profiles\pass;D:\CODEX\sos-card\SDK\components\profiles\pass_c;D:\CODEX\sos-card\SDK\components\profiles\pcs;D:\CODEX\sos-card\SDK\components\profiles\rscs;D:\CODEX\sos-card\SDK\components\profiles\rscs_c;D:\CODEX\sos-card\SDK\components\profiles\rtus;D:\CODEX\sos-card\SDK\components\profiles\sample;D:\CODEX\sos-card\SDK\components\profiles\ths;D:\CODEX\sos-card\SDK\components\profiles\ths_c;D:\CODEX\sos-card\SDK\components\profiles\tps;D:\CODEX\sos-card\SDK\components\profiles\otas;D:\CODEX\sos-card\SDK\components\sdk;D:\CODEX\sos-card\SDK\drivers\inc;D:\CODEX\sos-card\SDK\drivers\inc\hal;D:\CODEX\sos-card\SDK\external\freertos\include;D:\CODEX\sos-card\SDK\external\segger_rtt;D:\CODEX\sos-card\SDK\platform\arch\arm\cortex-m\cmsis\core\include;D:\CODEX\sos-card\SDK\platform\boards;D:\CODEX\sos-card\SDK\platform\include;D:\CODEX\sos-card\SDK\platform\soc\include;D:\CODEX\sos-card\SDK\platform\soc\linker\keil;D:\CODEX\sos-card\SDK\components\libraries\app_bootloader\sign_verify\inc;D:\CODEX\sos-card\SDK\components\libraries\app_crypto;D:\CODEX\sos-card\SDK\components\libraries\app_bootloader;D:\CODEX\sos-card\tools\ota\boot
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: D:\CODEX\sos-card\tools\ota\gr_boot\reference_only.sct
  link misc: D:\CODEX\sos-card\SDK\platform\soc\linker\keil\rom_symbol.txt
  group gr_startup
    D:/CODEX/sos-card/SDK/platform/arch/arm/cortex-m/keil/: Startup.S
  group gr_arch
    D:/CODEX/sos-card/SDK/platform/soc/common/: gr_system.c gr_interrupt.c gr_platform.c
  group gr_soc
    D:/CODEX/sos-card/SDK/platform/soc/src/: gr_soc.c
  group gr_board
    D:/CODEX/sos-card/SDK/platform/boards/: board_SK.c
  group gr_stack_lib
    D:/CODEX/sos-card/SDK/platform/soc/linker/keil/: ble_sdk.lib
  group gr_app_drivers
    D:/CODEX/sos-card/SDK/drivers/src/: app_dma.c app_io.c app_gpiote.c app_pwr_mgmt.c app_uart.c app_qspi.c app_qspi_dma.c app_spi.c app_spi_dma.c app_graphics_qspi.c
  group gr_libraries
    D:/CODEX/sos-card/SDK/components/libraries/app_assert/: app_assert.c
    D:/CODEX/sos-card/SDK/components/libraries/app_key/: app_key.c app_key_core.c
    D:/CODEX/sos-card/SDK/components/libraries/app_log/: app_log.c
    D:/CODEX/sos-card/SDK/components/libraries/app_timer/: app_timer.c
    D:/CODEX/sos-card/SDK/components/libraries/pmu_calibration/: pmu_calibration.c
    D:/CODEX/sos-card/SDK/components/libraries/ring_buffer/: ring_buffer.c
    D:/CODEX/sos-card/SDK/components/libraries/utility/: utility.c
    D:/CODEX/sos-card/SDK/components/libraries/dfu_port/: dfu_port.c
    D:/CODEX/sos-card/SDK/components/sdk/: ble.c
  group gr_crypto
    D:/CODEX/sos-card/SDK/components/libraries/app_crypto/keil/: app_crypto.lib
  group gr_profiles
    D:/CODEX/sos-card/SDK/components/profiles/common/: ble_prf_utils.c
    D:/CODEX/sos-card/SDK/components/profiles/otas/: otas.c
  group gr_drivers_ext
    D:/CODEX/sos-card/SDK/components/drivers_ext/gr55xx/: gr55xx_spi_flash.c
  group user_platform
    D:/CODEX/sos-card/tools/ota/gr_boot/Src/platform/: user_periph_setup.c
  group user_security
    D:/CODEX/sos-card/SDK/components/libraries/app_bootloader/sign_verify/src/: rsa.c pkc.c sign_verify.c
  group user_app
    D:/CODEX/sos-card/tools/ota/gr_boot/Src/user/: main.c bootloader_boot_port.c
    D:/CODEX/sos-card/SDK/components/libraries/app_bootloader/: bootloader_ota.c bootloader_boot_vendor.c
    D:/CODEX/sos-card/tools/ota/gr_boot/Src/config/: bootloader_config.h custom_config.h
  group SIZE_ONLY_transaction_core
    D:/CODEX/sos-card/ble_app_uart_c/Src/user/ota/: yp001_ota_boot.c
    D:/CODEX/sos-card/tools/ota/boot/: yp001_ota_flash.c yp001_ota_start.c
  group SIZE_ONLY_sdk_handoff
    D:/CODEX/sos-card/tools/ota/boot/: yp001_ota_sdk_handoff.c
  group SIZE_ONLY_project_verify
    D:/CODEX/sos-card/tools/ota/boot/: yp001_ota_project_verify.c
  group SIZE_ONLY_project_sdk
    D:/CODEX/sos-card/tools/ota/boot/: yp001_ota_project_sdk.c
  group SIZE_ONLY_project_entry
    D:/CODEX/sos-card/tools/ota/boot/: yp001_ota_entry.c
  group YP001_immutable_provision
    D:/CODEX/sos-card/tools/ota/gr_boot/Src/user/: yp001_boot_provision.c
